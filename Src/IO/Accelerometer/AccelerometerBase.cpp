///////////////////////////////////////////////////////////////////////
/// AccelerometerBase
///////////////////////////////////////////////////////////////////////

#include "stdafx.h"

#include "Core/Application.h"
#include "Core/Logs.h"

#include "Common/EventManager.h"

#include "Events/EvAcceleration.h"

#include "IO/Accelerometer/AccelerometerBase.h"

#include "Utils/Float.h"

#include <math.h>
#include <algorithm>

///////////////////////////////////////////////////////////////////////

// /////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////
// Ctors / Dtor
// /////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////
AccelerometerBase::AccelerometerBase()
{
	m_x = m_y = m_z = 0.f;
	m_prevAngleXY = m_prevAngleYZ = m_prevAngleZX = 0.f;

	_calcAngles();
	clear();
}

AccelerometerBase::~AccelerometerBase()
{
}


// /////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////
// Methods (Privates/Protected)
// /////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////
void AccelerometerBase::_trace(const char* msg) const
{
	if(SHOW_TRACE)
	{
		Logs::trace("AccelerometerBase", msg);
	}
}


void AccelerometerBase::_calcAngles()
{
	if(USE_ROLL)
	{
		m_prevAngleXY = m_angleXY;

		if(Float::areEquals(m_x, 0.f))	{m_angleXY = (m_prevAngleXY > 0.f) ? Float::HALF_PI : -Float::HALF_PI;}
		else							{m_angleXY = atan2(m_y, m_x);}
	}

	if(USE_PITCH)
	{
		m_prevAngleYZ = m_angleYZ;

		if(Float::areEquals(m_y, 0.f))	{m_angleYZ = (m_prevAngleYZ > 0.f) ? Float::HALF_PI : -Float::HALF_PI;}
		else							{m_angleYZ = atan2(m_z, m_y);}
	}

	if(USE_YAW)
	{
		m_prevAngleZX = m_angleXY;

		if(Float::areEquals(m_z, 0.f))	{m_angleZX = (m_prevAngleZX > 0.f) ? Float::HALF_PI : -Float::HALF_PI;}
		else							{m_angleZX = atan2(m_x, m_z);}
	}
}


// /////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////
// Methods
// /////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////
void AccelerometerBase::clear()
{
	m_minX = m_maxX = m_prevX = m_x;
	m_minX = m_maxX = m_prevY = m_y;
	m_minX = m_maxX = m_prevZ = m_z;
}


// /////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////
// Methods (Events)
// /////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////
void AccelerometerBase::moved(MOVE_TYPE x, MOVE_TYPE y, MOVE_TYPE z)
{
	_trace("Moved!!");

	//std::min(2, 3);

	m_x = x;
	m_y = y;
	m_z = z;

	m_minX = min(m_minX, x);	m_maxX = max(m_maxX, x);
	m_minY = min(m_minY, y);	m_maxY = max(m_maxY, y);
	m_minZ = min(m_minZ, z);	m_maxZ = max(m_maxZ, z);

	_calcAngles();

	__MGR_EVENTS()->raise( EvAcceleration(m_x, m_y, m_z) );
}


// /////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////
// Methods (IUpdatable impl.)
// /////////////////////////////////////////////////////////////////////////////////////////////////////////////////////////
void AccelerometerBase::update(TimeStamp timestamp)
{
	clear();
}