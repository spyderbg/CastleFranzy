//////////////////////////////////////////////////////////////////////////////////////////////////////////////////////
//////////////////////////////////////////////////////////////////////////////////////////////////////////////////////

#include "SourcesPool.h"

//////////////////////////////////////////////////////////////////////////////////////////////////////////////////////

CSourcesPool g_OpenAlSourcesPool;

//////////////////////////////////////////////////////////////////////////////////////////////////////////////////////

ALuint CSourcesPool::GetNextAvailableSource()
{
	for(int i = 0; i < m_noSources; i++)
	{
		if(!m_used[i])
		{
			m_used[i] = true;
			return m_sources[i];
		}
	}

	return (ALuint)0;
}

//////////////////////////////////////////////////////////////////////////////////////////////////////////////////////

void CSourcesPool::ReleaseSource(ALuint sourceId)
{
	for(int i = 0; i < m_noSources; i++)
	{
		if(sourceId == m_sources[i])
		{
			m_used[i] = false;
			break;
		}
	}
}

//////////////////////////////////////////////////////////////////////////////////////////////////////////////////////

void CSourcesPool::GenerateSources()
{
	if(m_noSources)
	{
		return;
	}

	// reset errors
	alGetError();

	for(int i = 0; i < MAX_CACHED_OPENAL_SOURCES; i++)
	{
		alGenSources(1,&m_sources[i]);

		if(alGetError() != AL_NO_ERROR)
		{
			break;
		}

		m_used[i]  = false;

		m_noSources++;
	}
}

//////////////////////////////////////////////////////////////////////////////////////////////////////////////////////

void CSourcesPool::DestroySources()
{
	for(int i = 0; i < m_noSources; i++)
	{
		alSourceStop(m_sources[i]);
		LOG_OPENAL_ERROR;

		alSourcei(m_sources[i], AL_BUFFER, 0);
		LOG_OPENAL_ERROR;

		alDeleteSources(1, &m_sources[i]);
		LOG_OPENAL_ERROR;
	}

	m_noSources = 0;
}

//////////////////////////////////////////////////////////////////////////////////////////////////////////////////////
//////////////////////////////////////////////////////////////////////////////////////////////////////////////////////
